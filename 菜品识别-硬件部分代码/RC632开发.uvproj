# Keil uVision project RC632开发.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: SL601F +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: MAIN.C SlRc632.C LCD1602.c
  group ISO15693
    ./: ISO15693.C
